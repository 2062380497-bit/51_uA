# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51_ua
  group Source Group 1
    ./: STARTUP.A51 main.c STC8G.H
